SUMMARY = "RAUC update bundle with a broken release (1.2.0-broken), for rollback tests"
require edge-bundle.inc
RAUC_SLOT_rootfs = "edge-image-broken"
RAUC_BUNDLE_VERSION = "1.2.0-broken"

SUMMARY = "RAUC update bundle: edge release 1.1.0"
require edge-bundle.inc
RAUC_SLOT_rootfs = "edge-image-update"
RAUC_BUNDLE_VERSION = "1.1.0"
